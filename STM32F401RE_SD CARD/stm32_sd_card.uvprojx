# Keil uVision project stm32_sd_card.uvprojx, settings and files
target stm32f401re (6150000::V6.15::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32_sd_card
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Main Application
    ./: main.c
  group FATFS Middleware
    ./: ccsbcs.c diskio.c diskio.h fatfs.c fatfs.h fatfs_sd.c fatfs_sd.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h ffconf.h integer.h user_diskio.c user_diskio.h
  group Peripheral Libraries
    ./: clock.c clock.h gpio.c gpio.h spi2.c spi2.h systick.c systick.h usart2.c usart2.h interrupt.c interrupt.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
