# Keil uVision project sd_card_3.uvprojx, settings and files
target stm32f401re (6150000::V6.15::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sd_card_3
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Main Application
    ./: main.c
  group FATFS
    ./: ff.c ff.h ffconf.h ccsbcs.c
  group High Layer API
    ./: diskio.c diskio.h sd_card.c sd_card.h serial.c serial.h integer.h
  group Low Layer API
    ./: clock.c clock.h gpio.c gpio.h spi.c spi.h systick.c systick.h uart.c uart.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
